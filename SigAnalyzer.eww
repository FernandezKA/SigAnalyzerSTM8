<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\Serial_bootloader\serial_bootloader.ewp</path>
    </project>
    <batchBuild />
</workspace>
